# IAR project cc1101.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x20
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: CC1101_LIB; TX
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: cc1101.srec
  ILINK.IlinkOutputFile: cc1101.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group user
    CC1101_LIB/: CC1101.c
    TX/: dataProcess.c main.c peripheral.c stm8s_it.c Tim.c
