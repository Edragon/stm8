# IAR project cc1101.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101F3P STM8L101F3P
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x40
  ICCSTM8.CCIncludePath2: CC1101_LIB; TX
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: cc1101.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group user
    CC1101_LIB/: CC1101.c
    TX/: dataProcess.c main.c peripheral.c stm8l10x_it.c Tim.c
