<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\stm8_minikit_test_code.ewp</path>
  </project>
  <batchBuild/>
</workspace>


