# IAR project Backup (3) of LED.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\My_Lib\delay; ..\User; ..\System; ..\My_Lib\LED
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LED.hex
  ILINK.IlinkOutputFile: LED.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group My_Lib
    ../My_Lib/delay/: delay.c
    ../My_Lib/LED/: led.c
  group User
    ../User/: main.c
