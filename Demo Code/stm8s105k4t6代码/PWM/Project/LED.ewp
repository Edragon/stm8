# IAR project LED.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\My_Lib\delay; ..\User; ..\System; ..\My_Lib\LED; ..\My_Lib\SPI; ..\My_Lib\USART; ..\My_Lib\AD; ..\My_Lib\EXIT; ..\My_Lib\PWM; ..\My_Lib\Time; ..\My_Lib\EXIT
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LED.hex
  ILINK.IlinkOutputFile: LED.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group My_Lib
    ../My_Lib/AD/: ADC.c
    ../My_Lib/delay/: delay.c
    ../My_Lib/EXIT/: EXIT.c
    ../My_Lib/LED/: led.c
    ../My_Lib/PWM/: PWM.c
    ../My_Lib/SPI/: spi.c
    ../My_Lib/Time/: Time.c
    ../My_Lib/USART/: USART.c
  group User
    ../User/: main.c
