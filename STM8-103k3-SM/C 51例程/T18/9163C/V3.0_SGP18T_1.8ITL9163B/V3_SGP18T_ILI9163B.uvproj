# Keil uVision project V3_SGP18T_ILI9163B.uvproj, settings and files
target 8051core (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: SGP18T_ILI9163B_V300 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DriverFiles
  group app
    ./: STARTUP.A51
    ./DriverFiles/: application.c
  group driver
    ./DriverFiles/: SGP18T_ILI9163B_base.c SGP18T_ILI9163B_figure.c SGP18T_ILI9163B_ascii.c
  group note
    ./: ReadMe.txt
